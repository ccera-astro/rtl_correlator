<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rtl_correlator</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>corr_data_probe</value></param>
<param><key>block_id</key><value>corr_output</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[complex(0.0)]*nvis</value></param>
<param><key>poll_rate</key><value>1.0/5.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>corr_rate</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delays</value></param>
<param><key>value</key><value>[0]*nchan</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filedump</value></param>
<param><key>value</key><value>True if (os.path.getsize("chan0.bin") &lt; rlimit or os.path.getsize("chan1.bin") &lt; rlimit) and state_prober != [9e9]*6 else False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>files</value></param>
<param><key>value</key><value>["chan0.bin", "chan1.bin", "chan2.bin", "chan3.bin","chan4.bin"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>logsts</value></param>
<param><key>value</key><value>rtl_corr_help.log(corr_data_probe,prefix)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchan</value></param>
<param><key>comment</key><value>UPDATE THIS IF YOU CHANGE NUMBER
OF CHANNELS</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nvis</value></param>
<param><key>value</key><value>(nchan * (nchan-1))/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phases</value></param>
<param><key>value</key><value>[0.0]*nchan</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rlimit</value></param>
<param><key>value</key><value>int(samp_rate*seconds*1.25*8)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>state_prober</value></param>
<param><key>block_id</key><value>corr_output</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0]*6</value></param>
<param><key>poll_rate</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sts</value></param>
<param><key>value</key><value>rtl_corr_help.st_update(state_prober,port,files,samp_rate,seconds)</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>enabled</key><value>filedump</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0_0</value></param>
<param><key>enabled</key><value>filedump</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0_0_0</value></param>
<param><key>enabled</key><value>filedump</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0_0_0_0</value></param>
<param><key>enabled</key><value>filedump</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0_0_0_0_0</value></param>
<param><key>enabled</key><value>filedump</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delays[0]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>delays[1]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>delays[2]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_1</value></param>
<param><key>delay</key><value>delays[3]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_1_0</value></param>
<param><key>delay</key><value>delays[4]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>files[0]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>files[1]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>files[2]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>files[3]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0_0</value></param>
<param><key>file</key><value>files[4]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>comment</key><value>Dont need high rate now
reduce to 'corr_rate' sps</value></param>
<param><key>n</key><value>int(samp_rate/corr_rate)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>corr_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2</value></param>
<param><key>n</key><value>1 if phases != [0.0]*nchan else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2_0</value></param>
<param><key>n</key><value>1 if phases != [0.0]*nchan else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2_0_0</value></param>
<param><key>n</key><value>1 if phases != [0.0]*nchan else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2_0_0_0</value></param>
<param><key>n</key><value>1 if phases != [0.0]*nchan else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2_0_0_1</value></param>
<param><key>n</key><value>1 if phases != [0.0]*nchan else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_2</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_3</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_4</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_4_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_4_0_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_4_0_1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0_4_0_2</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>complex(math.cos(phases[0]),math.sin(phases[0]))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>complex(math.cos(phases[1]),math.sin(phases[1]))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>complex(math.cos(phases[2]),math.sin(phases[2]))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>complex(math.cos(phases[3]),math.sin(phases[3]))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0_0</value></param>
<param><key>const</key><value>complex(math.cos(phases[4]),math.sin(phases[4]))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>nvis</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>corr_output</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>label</key><value>Device string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"rtl=0 rtl=1 rtl=2 rtl=3"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1417.0e6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Delay/Phase adjustment
Also we run the correlator sub-graph at
low rate until we know what the phases
and delays are</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>The 6 correlators
4 antennae
gives:
(4 * (4-1)) / 2

possible visibilities (nvis)</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>A radio astronomy 5-channel
correlator
Produces 10 complex visibilities 
from the 5 antennae inputs
Could be used with new KrakenSDR</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>comment</key><value>We record baseband samples in a set of
files.

Once those files have a little more than "seconds"
worth of samples in them, a helper function
computes the relative delays and phases
and updates the

delays[] and phases[]

variables</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rfgain</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>dc_offset_mode1</key><value>0</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>freq</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>iq_balance_mode1</key><value>0</value></param>
<param><key>gain1</key><value>rfgain</value></param>
<param><key>bb_gain2</key><value>20</value></param>
<param><key>dc_offset_mode2</key><value>0</value></param>
<param><key>corr2</key><value>0</value></param>
<param><key>freq2</key><value>freq</value></param>
<param><key>gain_mode2</key><value>False</value></param>
<param><key>if_gain2</key><value>20</value></param>
<param><key>iq_balance_mode2</key><value>0</value></param>
<param><key>gain2</key><value>rfgain</value></param>
<param><key>bb_gain3</key><value>20</value></param>
<param><key>dc_offset_mode3</key><value>0</value></param>
<param><key>corr3</key><value>0</value></param>
<param><key>freq3</key><value>freq</value></param>
<param><key>gain_mode3</key><value>False</value></param>
<param><key>if_gain3</key><value>20</value></param>
<param><key>iq_balance_mode3</key><value>0</value></param>
<param><key>gain3</key><value>rfgain</value></param>
<param><key>bb_gain4</key><value>20</value></param>
<param><key>dc_offset_mode4</key><value>0</value></param>
<param><key>corr4</key><value>0</value></param>
<param><key>freq4</key><value>freq</value></param>
<param><key>gain_mode4</key><value>False</value></param>
<param><key>if_gain4</key><value>20</value></param>
<param><key>iq_balance_mode4</key><value>0</value></param>
<param><key>gain4</key><value>rfgain</value></param>
<param><key>args</key><value>device</value></param>
<param><key>nchan</key><value>5</value></param>
<param><key>num_mboards</key><value>5</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>XMLRPC Port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4040</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>Filename prefix for output</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>./</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>rtl_corr_help</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import os
import numpy
import xmlrpclib as xmlrpc
import time
doneffts = False
def st_update(pace,port,files,srate,secs):
    global doneffts
    
    #
    # We've already done this, leave without doing anything
    #
    if (doneffts == True):
        return 1
    
    #
    # Compute how many bytes are required in the capture files
    #
    needed = int(srate * secs * 8.0)
    doit = True
    
    #
    # Check each file to make sure that it is big enough
    #
    for f in files:
        if (os.path.exists(f) != True):
            doit = False
            break
        if (os.path.getsize(f) &lt; needed):
            doit = False
    
    # We go here, time to do cross correlation using
    #   FFT-based fast convolution
    #
    if doit == True and doneffts == False:
        
        #
        # Make up a channel list consisting of buffers from the
        #  capture files
        #
        chans = []
        for f in files:
            chans.append(numpy.fromfile(f,dtype=numpy.csingle,sep=""))
        
        #
        # Pad the data with zeros to improve resolution
        #
        for i in range(len(chans)):
            
            #
            # Truncate to exactly "secs" worth of samples
            #
            chans[i] = chans[i][:int(srate*secs)]
            
            #
            # First channel is special--pad order is different
            #
            if (i == 0):
                chans[i] += numpy.zeros(len(chans[i]),dtype=numpy.csingle)
            else:
                chans[i] = numpy.zeros(len(chans[i]),dtype=numpy.csingle)+chans[i]
        
        #
        # Now we have a list of FFTs to compute on the padded channel data
        #
        ffts = []
        for i in range(len(chans)):
            ffts.append(numpy.fft.fft(chans[i]))
            time.sleep(0.25)
        iffts = []
        
        #
        # Now we need to do  conjugate multiply on each of the
        #  channels against channel 0
        #
        conjugate = numpy.conj(ffts[0])
        for i in range(1,len(chans)):
            conjm = numpy.multiply(conjugate,ffts[i])
            iffts.append(numpy.fft.ifft(conjm))
            time.sleep(0.25)
        
        #
        # Now we extract the location of max correlation
        #
        offsets = [0]
        phases = [0]
        for i in range(len(iffts)):
            magn = numpy.multiply(numpy.absolute(iffts[i]),numpy.absolute(iffts[i]))
            mx = numpy.argmax(magn)
            mc = iffts[i][mx]
            offsets.append(int(mx))
            phases.append(float(numpy.angle(mc)))
            time.sleep(0.125)
        doneffts = True
        try:
            handle =  xmlrpc.ServerProxy("http://localhost:%d" % port, allow_none=True)
        except:
            return 0
        mxd = max(offsets)
        ndx = 0
        #
        # Adjust delays an phases
        #
        for o in offsets:
            offsets[ndx] = mxd - offsets[ndx]
            phases[ndx] *= -1
            ndx += 1
        handle.set_delays(offsets)
        
        #
        # Invert phases
        #
        handle.set_phases(phases)
        print "Delays " + str(offsets)
        print "Phases " + str(phases)
    return (0 if doneffts == 0 else 1)

def log(d,prefix):
    ltp = time.gmtime()
    fn = prefix+"%d%02d%02d.csv" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    fp = open(fn, "a")
    fp.write("%02d,%02d,%02d," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))
    ndx = 0
    for v in d:
        fp.write("%11.9f,%11.9f" % (v.real, v.imag))
        if (ndx &lt; len(d)-1):
            fp.write(",")
        ndx += 1
    fp.write("\n")
        
    print d
</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>seconds</value></param>
<param><key>label</key><value>Seconds of capture buffer</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(samp_rate/corr_rate)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0</value></param>
<param><key>alpha</key><value>1.0/(corr_rate*0.75)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0_0_0</value></param>
<param><key>alpha</key><value>1.0/(corr_rate*300)</value></param>
<param><key>comment</key><value>Implement DC block</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>nvis</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0e6</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>logging</key><value>False</value></param>
<param><key>port</key><value>port</value></param>
</block>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0_0_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_keep_one_in_n_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_1</source_block_id><sink_block_id>blocks_keep_one_in_n_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_1_0</source_block_id><sink_block_id>blocks_keep_one_in_n_2_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>corr_output</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2_0_0_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_2</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_3</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_4</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_4_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_4_0_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_4_0_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0_4_0_2</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0_4_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_copy_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_copy_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_copy_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_copy_0_0_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_delay_0_0_1_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
